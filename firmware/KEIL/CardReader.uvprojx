# Keil uVision project CardReader.uvprojx, settings and files
target CardReader (5060960::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL
  output: CardReader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F407,USE_LEGACY_KEIL
  c include: ..\CMSIS;..\Inc;..\Middlewares\mfrc522;..\Middlewares\ecc
  scatter file: .\CardReader.sct
  group Startup
    ../Startup/: startup_gd32f407.s
  group CMSIS
    ../Src/: system_gd32f407.c
  group Drivers
    ../Src/: bsp.c spi_bus.c usb_msc.c
  group Middlewares
    ../Middlewares/mfrc522/: mfrc522.c
    ../Middlewares/ecc/: ecc_p256.c
  group Application
    ../Src/: main.c
